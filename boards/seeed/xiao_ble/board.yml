## boards/seeed/xiao_ble/board.yml
```yaml
board:
  extend: xiao_ble
  variants:
    - name: flash
      qualifier: nrf52840
```
